Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture]
File name: 0001
Time: 2023-05-23T15:41:06
Author: Iperboole srl, info@iperboole.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.50.27 - Exporter 21.2.1.0 - Alternate UI 21.2.1.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 23 15:41:06 2023 * Host: DESKTOP-EF0D6F5 * Database: C:\Users\FRANCE~1\AppData\Local\Temp\9cfa61fd-fc0a-459d-8ab3-0ce2c6f543f3\7de5cc45-04aa-40a5-b2a5-a2ef88725db1\ifc * Database version: 5507 * Database creation date: Tue May 23 15:41:05 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 23 15:41:06 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 23 15:41:06 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Refineair-Mockup

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Maggio 2023; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Refineair; Nome del progetto: Refineair-Mockup; Numero del progetto: 0001
Dati identità - Autore: Iperboole srl

# IfcBuildingStorey: Livello:Estremità 8 mm, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Grafica(Type) - Colore: 0; Modello di linea: Centro (2); Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1

# IfcDistributionControlElement: AE-Remote_Debugger:AE-Remote_Debugger, AE-Remote_Debugger:AE-Remote_Debugger:1068422
In: Livello 1
Type - Material: Logo-Blu
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: AE-Remote_Debugger
Type - Dati identità - Nome del tipo: AE-Remote_Debugger; Numero OmniClass: 23.85.30.21; Titolo OmniClass: Environmental Detection/Registration
Type - Vincoli - Prospetto di default: 0 mm
Material: Logo-Blu, Logo-Verde, Plastica_Bianca, Ingombro
Pset_QuantityTakeOff - Reference: AE-Remote_Debugger
Altro - Famiglia: AE-Remote_Debugger: AE-Remote_Debugger; Famiglia e tipo: AE-Remote_Debugger: AE-Remote_Debugger; ID tipo: AE-Remote_Debugger: AE-Remote_Debugger; Tipo: AE-Remote_Debugger: AE-Remote_Debugger
Costruzione - Peso: 0.5 kg
Dati - Certificazioni txt: https://www.refineair.it/certificati-e-test/certificazioni; LOD: F; Manuale manutenzione txt: https://www.refineair.it/download/; Manuale uso txt: https://www.refineair.it/download/; TABELLA: Remote_Debugger
Dati identità - Codice prodotto: RD; Modellato da: Iperboole srl; Nome prodotto: REMOTE DEBUGGER; Prodotto da: Refineair
Dimensioni - Altezza: 85 mm; Area: 0.276058 m2; Larghezza: 100 mm; Profondita: 32 mm; Volume: 0.0259225 m3
Elettrico - Fasi: 1; Frequenza: 50 Hz; IN: 0.1 A; Potenza assorbita: 0 W; Tensione corrente: 230 V
Elettrico - Circuiti - Dati elettrici: 230 V/1-0 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Livello : Livello 1; Livello: Livello: Livello 1; Offset da host: 0 mm; Quota altimetrica da livello: 0 mm
Visibilità - Ingombro: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
